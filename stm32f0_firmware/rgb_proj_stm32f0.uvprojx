# Keil uVision project rgb_proj_stm32f0.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F051R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: rgb_proj_stm32f0
  c flags: Optim=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group src
    ./: main.c uart.c tim1_pwm.c
  group ::Device
    RTE/Device/STM32F051R8/: startup_stm32f051.s system_stm32f0xx.c
software components: CMSIS:CORE 3.30.0, Device:Startup 1.4.0
